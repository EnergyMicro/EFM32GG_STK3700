# IAR project mpu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mpu.bin
  ILINK.IlinkOutputFile: mpu.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_lcd.c em_mpu.c em_rtc.c em_system.c
  group Source
    ../: mpu.c
