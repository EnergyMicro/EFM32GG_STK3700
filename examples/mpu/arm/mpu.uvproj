# Keil uVision project mpu.uvproj, settings and files
target mpu (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: mpu
  AfterMake: fromelf.exe --bin --output obj\mpu.bin obj\mpu.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\EnergyMicro\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_lcd.c em_mpu.c em_rtc.c em_system.c
  group Source
    ../: mpu.c
